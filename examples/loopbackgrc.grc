<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>20000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_1</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>20000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_2_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>10000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_3</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>20000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>6</value></param>
<param><key>minsize</key><value>6</value></param>
</block>
<block>
<key>dflood_dflood</key>
<param><key>id</key><value>dflood_dflood_0</value></param>
<param><key>addr</key><value>0</value></param>
<param><key>EMAalpha</key><value>0.8</value></param>
<param><key>broadcast_interval</key><value>10</value></param>
<param><key>data_to_file</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>errors_to_file</key><value>False</value></param>
<param><key>FEC</key><value>None</value></param>
<param><key>Plt</key><value>120</value></param>
<param><key>Slt</key><value>50</value></param>
<param><key>Ndupl</key><value>2</value></param>
<param><key>Tmax</key><value>65</value></param>
<param><key>Tmin</key><value>5</value></param>
<param><key>my_sink_addr</key><value>0</value></param>
<param><key>R</key><value>2</value></param>
</block>
<block>
<key>dflood_dflood</key>
<param><key>id</key><value>dflood_dflood_1</value></param>
<param><key>addr</key><value>1</value></param>
<param><key>EMAalpha</key><value>0.8</value></param>
<param><key>broadcast_interval</key><value>20</value></param>
<param><key>data_to_file</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>errors_to_file</key><value>False</value></param>
<param><key>FEC</key><value>None</value></param>
<param><key>Plt</key><value>120</value></param>
<param><key>Slt</key><value>50</value></param>
<param><key>Ndupl</key><value>0</value></param>
<param><key>Tmax</key><value>5</value></param>
<param><key>Tmin</key><value>1</value></param>
<param><key>my_sink_addr</key><value>0</value></param>
<param><key>R</key><value>2</value></param>
</block>
<block>
<key>dflood_dflood</key>
<param><key>id</key><value>dflood_dflood_3</value></param>
<param><key>addr</key><value>3</value></param>
<param><key>EMAalpha</key><value>0.8</value></param>
<param><key>broadcast_interval</key><value>20</value></param>
<param><key>data_to_file</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>errors_to_file</key><value>False</value></param>
<param><key>FEC</key><value>None</value></param>
<param><key>Plt</key><value>120</value></param>
<param><key>Slt</key><value>50</value></param>
<param><key>Ndupl</key><value>2</value></param>
<param><key>Tmax</key><value>65</value></param>
<param><key>Tmin</key><value>5</value></param>
<param><key>my_sink_addr</key><value>0</value></param>
<param><key>R</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>dflood_dflood_0</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_1</source_block_id><sink_block_id>dflood_dflood_1</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_2_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_3</source_block_id><sink_block_id>dflood_dflood_3</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>dflood_dflood_3</sink_block_id><source_key>pdus</source_key><sink_key>from_app</sink_key></connection>
<connection><source_block_id>dflood_dflood_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>to_app</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>dflood_dflood_0</source_block_id><sink_block_id>dflood_dflood_1</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>dflood_dflood_1</source_block_id><sink_block_id>dflood_dflood_0</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>dflood_dflood_1</source_block_id><sink_block_id>dflood_dflood_3</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>dflood_dflood_3</source_block_id><sink_block_id>dflood_dflood_1</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
</flow_graph>
